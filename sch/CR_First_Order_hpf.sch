** sch_path: sch/CR_First_Order_hpf.sch
**.subckt CR_First_Order_hpf in gref out
*.ipin in
*.iopin gref
*.opin out
R1 out gref 1k m=1
C1 in out 1p m=1
**.ends
.end
