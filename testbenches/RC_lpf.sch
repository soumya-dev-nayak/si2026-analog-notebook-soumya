** sch_path: testbenches/RC_lpf.sch
**.subckt RC_lpf in ref out
*.ipin in
*.iopin ref
*.opin out
R1 out in 1k m=1
C1 out ref 1p m=1
**.ends
.end
